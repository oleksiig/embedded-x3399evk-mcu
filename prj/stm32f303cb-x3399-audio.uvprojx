# Keil uVision project stm32f303cb-x3399-audio.uvprojx, settings and files
target STM32F303CB-X3399-AUDIO (ARM-GNU)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ..\bin\fw.elf
  AfterMake: arm-none-eabi-size ..\bin\fw.elf
  group board
    ../src/: board.c main.c host_interface.c keys_handler.c i2s_clocks.c
  group framework
    ../../../framework/hal/cortex-m/: irq-cm.c systick-cm.c svcall-cm.c
    ../../../framework/utils/: strutils.c
    ../../../framework/utils/memory/: allocator.c heap.c routines.c
    ../../../framework/utils/init/: init.c
    ../../../framework/hal/stm32f3/: clock.c mcu.c irq.c gpio.c i2c.c
